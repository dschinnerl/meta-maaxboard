require recipes-kernel/linux/linux-maaxboard-src-${PV}.inc
# require recipes-kernel/linux/linux-maaxboard-src-5.15.inc
# https://www.yoctoproject.org/pipermail/poky/2010-December/000953.html

# SRCREV = "81060a226b4e173a9ba7bc4c1379dc9efb7a035e"
SRCREV = "maaxboard_5.10.35_2.0.0"
