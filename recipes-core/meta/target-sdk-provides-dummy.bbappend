DUMMYPROVIDES_PACKAGES:remove:maaxboardbase = " \
    bash \
"