# ATF_PLATFORM = "imx8mq"
# IMX_BOOT_SOC_TARGET = "iMX8M"

PLATFORM_FLAVOR_maaxboard   = "imx8mqevk"
PLATFORM_FLAVOR_maaxboardmini   = "imx8mmevk"
PLATFORM_FLAVOR_maaxboardnano   = "imx8mnevk"
